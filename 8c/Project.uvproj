# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2131/01 NXP
  cpu: IRAM(0x40000000-0x40001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Project +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x40000000 size 0x2000
  group Source Group 1
    ./: Startup.s led.cpp led.h main.cpp stepper.cpp keyboard.cpp ledinv.cpp keyboard.h ledinv.h stepper.h
